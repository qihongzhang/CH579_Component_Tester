# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: CH579F WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG,BLE_MAC=TRUE,CLK_OSC32K=1
  c include: .\StdPeriphDriver\inc;.\CMSIS\Include;.\Startup
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./Startup/: startup_ARMCM0.s
  group StdPeriphDriver
    ./StdPeriphDriver/: CH57x_adc.c CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_int.c CH57x_lcd.c CH57x_pwm.c CH57x_pwr.c CH57x_spi0.c CH57x_spi1.c CH57x_sys.c CH57x_timer0.c CH57x_timer1.c CH57x_timer2.c CH57x_timer3.c CH57x_uart0.c CH57x_uart1.c CH57x_uart2.c CH57x_uart3.c CH57x_usbdev.c
  group USER
    ./USER/: main.c
